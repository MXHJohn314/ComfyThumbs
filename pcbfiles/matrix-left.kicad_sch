File: pcbfiles/matrix-left.kicad_sch (KiCad schematic)
At the start: 72 parts

Commit message: schematic changes
Parts:
- gave numbers to parts that had none: 72
